# Keil uVision project SWM341_UserBoot.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: SWM341_UserBoot
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM341_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_port.c SWM341_gpio.c SWM341_exti.c SWM341_timr.c SWM341_uart.c SWM341_adc.c SWM341_dma.c SWM341_i2c.c SWM341_pwm.c SWM341_can.c SWM341_spi.c SWM341_lcd.c SWM341_flash.c SWM341_crc.c SWM341_rtc.c SWM341_wdt.c SWM341_cordic.c SWM341_sleep.c SWM341_usbd.c SWM341_div.c SWM341_sdio.c SWM341_sdram.c SWM341_dac.c SWM341_jpeg.c SWM341_sfc.c SWM341_dma2d.c SWM341_iofilt.c SWM341_qei.c SWM341_usbh.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
